# Keil uVision project USB_CDC_Clear.uvprojx, settings and files
target USB_CDC_Clear Configuration (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USB_CDC_Clear Configuration +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,USE_USB,USE_GEN,USE_SCOPE
  c misc: --C99
  c include: ..\..\STM32F4\Inc;..\..\STM32F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\STM32F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\STM32F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\STM32F4\Drivers\CMSIS\Include;..\..\STM32F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\STM32F4\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\STM32F4\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\STM32F4\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Common
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../STM32F4/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c usbd_cdc_if.c main.c usb_device.c usbd_desc.c usbd_conf.c tim.c dma.c dac.c adc.c gpio.c freertos.c usart.c comms_hal.c
  group Application/MDK-ARM
    ../../STM32F4/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Middlewares/USB_Device_Library
    ../../STM32F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../../STM32F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/CMSIS
    ../../STM32F4/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../STM32F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_dac.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c
  group Middlewares/FreeRTOS
    ../../STM32F4/Middlewares/Third_Party/FreeRTOS/Source/: tasks.c timers.c queue.c croutine.c list.c
    ../../STM32F4/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../STM32F4/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../STM32F4/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Common
    ../../Common/: cmd_parser.c comms.c scope.c generator.c
software components: CMSIS:CORE 4.2.0
